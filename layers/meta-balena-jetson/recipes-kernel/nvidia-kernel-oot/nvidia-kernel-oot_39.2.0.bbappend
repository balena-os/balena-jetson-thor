# Building below driver is disabled in the sources
TEGRA_OOT_VIRTUALIZATION_DRIVERS:remove = "${KERNEL_MODULE_PACKAGE_PREFIX}kernel-module-hvc-sysfs"
TEGRA_OOT_REPLACEMENT_DRIVERS += " lan743x "

