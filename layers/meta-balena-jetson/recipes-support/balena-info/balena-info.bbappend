TTYS = "ttyUTC0 tty0 tty1"
