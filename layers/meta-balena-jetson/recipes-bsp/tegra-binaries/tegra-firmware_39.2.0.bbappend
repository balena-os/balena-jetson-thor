DEPENDS += "xz-native"
